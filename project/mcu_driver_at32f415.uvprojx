# Keil uVision project mcu_driver_at32f415.uvprojx, settings and files
target mcu_driver_at32f415 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: mcu_driver_at32f415 (library)
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,LIBRARY_VERSION
  c include: ..\source;..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ../source/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group include
    ../include/: arm_common_tables.h arm_const_structs.h arm_math.h at32f4xx.h at32f4xx_acc.h at32f4xx_adc.h at32f4xx_bkp.h at32f4xx_can.h at32f4xx_comp.h at32f4xx_conf.h at32f4xx_crc.h at32f4xx_dac.h at32f4xx_dbgmcu.h at32f4xx_dma.h at32f4xx_ertc.h at32f4xx_eth.h at32f4xx_exti.h at32f4xx_flash.h at32f4xx_gpio.h at32f4xx_gpio_ex.h at32f4xx_i2c.h at32f4xx_iwdg.h at32f4xx_pwr.h at32f4xx_rcc.h at32f4xx_rtc.h at32f4xx_sdio.h at32f4xx_spi.h at32f4xx_syscfg.h at32f4xx_tim.h at32f4xx_usart.h at32f4xx_wwdg.h at32f4xx_xmc.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h cmsis_iar.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h misc.h system_at32f4xx.h
